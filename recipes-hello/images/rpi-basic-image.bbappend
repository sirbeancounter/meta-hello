IMAGE_INSTALL += "erlang hello"
