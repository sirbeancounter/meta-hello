RDEPENDS_packagegroup-core-full-cmdline-sys-services_remove = "cronie"
RDEPENDS_packagegroup-core-full-cmdline-sys-services_remove = "lighttpd"
