IMAGE_INSTALL += "erlang hello"
IMAGE_FEATURES_remove = "splash"
